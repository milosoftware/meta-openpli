require oscam-common.inc

SRC_ORIGIN ?= "git://github.com/oscam-mirror/oscam-emu.git;protocol=https;branch=master"

CAMTITLE = "OSCam-Emu ${PV}: Open Source Softcam with Emulator"
CAMNAME = "oscam-emu"
